# Keil uVision project TinyDu.uvprojx, settings and files
target TinyDu (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: TinyDu
  AfterMake: fromelf --bin !L --output TinyDu.bin
  c flags: Optim=2 uC99=1
  c define: Z_SOLO
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --restrict -D__ASSERT_MSG -DTARGET_MCU_K64F --no_rtti -DDEVICE_SLEEP=1 -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_SERIAL_FC=1 -g -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DARM_MATH_CM4 -DDEVICE_SPISLAVE=1 -O0 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DFEATURE_IPV4=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DTARGET_K64F -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 --brief_diagnostics -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DFSL_RTOS_MBED --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTOOLCHAIN_ARM -DTARGET_DEBUG --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBEDTLS_ENTROPY_HARDWARE_ALT -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DMBED_BUILD_TIMESTAMP=1482723248.58 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -D__MBED_CMSIS_RTOS_CM
  c include: ..\..\.;..\..\IoT-OS;..\..\IoT-OS\boards;..\..\IoT-OS\doc;..\..\IoT-OS\external;..\..\IoT-OS\external\cjson;..\..\IoT-OS\external\mbedfs;..\..\IoT-OS\external\mbedfs\fat;..\..\IoT-OS\external\mbedfs\fat\ChaN;..\..\IoT-OS\external\mbedfs\sd;..\..\IoT-OS\external\mbed_client;..\..\IoT-OS\external\mbed_client\mbed-client-c;..\..\IoT-OS\external\mbed_client\mbed-client-c\nsdl-c;..\..\IoT-OS\external\mbed_client\mbed-client-c\source;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libCoap;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libCoap\src;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libCoap\src\include;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libNsdl;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libNsdl\src;..\..\IoT-OS\external\mbed_client\mbed-client-c\source\libNsdl\src\include;..\..\IoT-OS\external\mbed_client\mbed-trace;..\..\IoT-OS\external\mbed_client\mbed-trace\mbed-trace;..\..\IoT-OS\external\mbed_client\nanostack-libservice;..\..\IoT-OS\external\mbed_client\nanostack-libservice\mbed-client-libservice;..\..\IoT-OS\external\mbed_client\nanostack-libservice\mbed-client-libservice\platform;..\..\IoT-OS\external\mp3dec;..\..\IoT-OS\external\mp3dec\pub;..\..\IoT-OS\external\mp3dec\real;..\..\IoT-OS\external\speex;..\..\IoT-OS\external\speex\include;..\..\IoT-OS\external\speex\include\speex;..\..\IoT-OS\external\speex\libspeex;..\..\IoT-OS\external\speex\wavfmt;..\..\IoT-OS\external\targets_ext;..\..\IoT-OS\external\targets_ext\TARGET_K64F;..\..\IoT-OS\external\targets_ext\TARGET_K64F\VS1053;..\..\IoT-OS\main;..\..\IoT-OS\projects;..\..\IoT-OS\src;..\..\IoT-OS\src\baidu-speedx;..\..\IoT-OS\src\httpclient-c;..\..\IoT-OS\src\iot-baidu-ca;..\..\IoT-OS\src\iot-baidu-ca\include;..\..\IoT-OS\src\iot-baidu-ca\source;..\..\IoT-OS\src\iot-baidu-ca-adapter;..\..\IoT-OS\src\iot-baidu-ca-scheduler;..\..\IoT-OS\src\media-player;..\..\IoT-OS\src\mp3_data_mgr;..\..\IoT-OS\src\recorder;..\..\IoT-OS\tools;..\..\IoT-OS\tools\mbed-os;..\..\IoT-OS\tools\mbed-os\tools;..\..\mbed-os;..\..\mbed-os\docs;..\..\mbed-os\features;..\..\mbed-os\features\frameworks;..\..\mbed-os\features\frameworks\greentea-client;..\..\mbed-os\features\frameworks\greentea-client\greentea-client;..\..\mbed-os\features\frameworks\greentea-client\source;..\..\mbed-os\features\frameworks\unity;..\..\mbed-os\features\frameworks\unity\source;..\..\mbed-os\features\frameworks\unity\unity;..\..\mbed-os\features\frameworks\utest;..\..\mbed-os\features\frameworks\utest\source;..\..\mbed-os\features\frameworks\utest\utest;..\..\mbed-os\features\mbedtls;..\..\mbed-os\features\mbedtls\importer;..\..\mbed-os\features\mbedtls\inc;..\..\mbed-os\features\mbedtls\inc\mbedtls;..\..\mbed-os\features\mbedtls\src;..\..\mbed-os\features\net;..\..\mbed-os\features\net\network-socket;..\..\mbed-os\features\storage;..\..\mbed-os\hal;..\..\mbed-os\hal\api;..\..\mbed-os\hal\common;..\..\mbed-os\hal\hal;..\..\mbed-os\hal\hal\storage_abstraction;..\..\mbed-os\hal\targets;..\..\mbed-os\hal\targets\cmsis;..\..\mbed-os\hal\targets\cmsis\TARGET_Freescale;..\..\mbed-os\hal\targets\cmsis\TARGET_Freescale\TARGET_MCU_K64F;..\..\mbed-os\hal\targets\cmsis\TARGET_Freescale\TARGET_MCU_K64F\TOOLCHAIN_ARM_STD;..\..\mbed-os\hal\targets\hal;..\..\mbed-os\hal\targets\hal\TARGET_Freescale;..\..\mbed-os\hal\targets\hal\TARGET_Freescale\TARGET_KSDK2_MCUS;..\..\mbed-os\hal\targets\hal\TARGET_Freescale\TARGET_KSDK2_MCUS\api;..\..\mbed-os\hal\targets\hal\TARGET_Freescale\TARGET_KSDK2_MCUS\TARGET_MCU_K64F;..\..\mbed-os\hal\targets\hal\TARGET_Freescale\TARGET_KSDK2_MCUS\TARGET_MCU_K64F\drivers;..\..\mbed-os\hal\targets\hal\TARGET_Freescale\TARGET_KSDK2_MCUS\TARGET_MCU_K64F\TARGET_FRDM;..\..\mbed-os\rtos;..\..\mbed-os\rtos\rtos;..\..\mbed-os\rtos\rtx;..\..\mbed-os\rtos\rtx\TARGET_CORTEX_M;..\..\mbed-os\rtos\rtx\TARGET_CORTEX_M\TARGET_RTOS_M4_M7;..\..\mbed-os\rtos\rtx\TARGET_CORTEX_M\TARGET_RTOS_M4_M7\TOOLCHAIN_ARM;..\..\.;..\..\mbed-os\features\storage\FEATURE_STORAGE;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\configuration-store;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design\pics;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design\umlet;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\project;..\..\mbed-os\features\storage\FEATURE_STORAGE\cfstore\source;..\..\mbed-os\features\storage\FEATURE_STORAGE\flash-journal;..\..\mbed-os\features\storage\FEATURE_STORAGE\flash-journal\flash-journal-strategy-sequential;..\..\mbed-os\features\net\FEATURE_IPV4;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\api;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\core;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\core\ipv4;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\core\snmp;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\include;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\include\ipv4;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\include\ipv4\lwip;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\include\lwip;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\include\netif;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\netif;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip\netif\ppp;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-eth;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-eth\arch;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-eth\arch\TARGET_Freescale;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-sys;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-sys\arch;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-wifi;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-wifi\arch;..\..\IoT-OS\src\iot-baidu-ota;..\src\vs10xx;..\..\IoT-OS\src\iot-baidu-ota\baidu_ota_unpack;..\..\IoT-OS\src\iot-baidu-ota\baidu_ota_unpack\ota\inc;..\..\IoT-OS\src\iot-baidu-ota\baidu_ota_unpack\zliblite;..\boards\TARGET_K64F;..\src\media;..\..\mbed-os\features\net\FEATURE_IPV4\lwip-interface\lwip-wifi\arch\TARGET_RDA\TARGET_UNO_91H\inc;..\boards\TARGET_RDA
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DFSL_RTOS_MBED,-DMBEDTLS_ENTROPY_HARDWARE_ALT,-D__CORTEX_M4,-D__FPU_PRESENT=1,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\mbed-os\hal\targets\cmsis\TARGET_Freescale\TARGET_MCU_K64F\TOOLCHAIN_ARM_STD\MK64FN1M0xxx12.sct
  group ChaN
    ../../IoT-OS/external/mbedfs/fat/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
  group TARGET_CORTEX_M
    ../../mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
  group TARGET_FRDM
    ../../mbed-os/hal/targets/hal/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.c crc.h device.h fsl_clock_config.c fsl_clock_config.h fsl_phy.c fsl_phy.h mbed_overrides.c PeripheralNames.h PeripheralPins.c PinNames.h
  group TARGET_Freescale
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip-eth/arch/TARGET_Freescale/: hardware_init_MK64F12.c k64f_emac.c k64f_emac_config.h lwipopts_conf.h
  group TARGET_MCU_K64F
    ../../mbed-os/hal/targets/cmsis/TARGET_Freescale/TARGET_MCU_K64F/: cmsis.h cmsis_nvic.c cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
    ../../mbed-os/hal/targets/hal/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/: entropy_hardware_poll.c peripheral_clock_defines.h pwmout_api.c serial_api.c spi_api.c storage_driver.c us_ticker.c
    ../boards/TARGET_K64F/: flash.c flash.h FreescaleIAP.c FreescaleIAP.h
  group TOOLCHAIN_ARM
    ../../mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    ../../mbed-os/hal/targets/cmsis/TARGET_Freescale/TARGET_MCU_K64F/TOOLCHAIN_ARM_STD/: startup_MK64F12.S sys.cpp
  group TinyDu
    ./: mbed_config.h
  group VS1053
    ../../IoT-OS/external/targets_ext/TARGET_K64F/VS1053/: vs10xx.cpp vs10xx.h
    ../src/vs10xx/: baidu_os_vs10xx_base.cpp
  group api
    ../../mbed-os/hal/api/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h rtc_time.h semihost_api.h Serial.h SerialBase.h SingletonPtr.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h wait_api.h
    ../../mbed-os/hal/targets/hal/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: analogin_api.c analogout_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h rtc_api.c sleep.c
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
  group arch
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
  group baidu-speedx
    ../../IoT-OS/src/baidu-speedx/: baidu_speex.h
    ../src/baidu-speedx/: baidu_speex.cpp
  group cjson
    ../../IoT-OS/external/cjson/: baidu_json.c baidu_json.h
  group cmsis
    ../../mbed-os/hal/targets/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group common
    ../../mbed-os/hal/common/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_gpio.c mbed_interface.c mbed_lp_ticker_api.c mbed_mem_trace.c mbed_pinmap_common.c mbed_rtc_time.cpp mbed_semihost_api.c mbed_ticker_api.c mbed_us_ticker_api.c mbed_wait_api.c RawSerial.cpp retarget.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group configuration-store
    ../../mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store/: configuration_store.h
  group core
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/core/: lwip_def.c lwip_dhcp.c lwip_dns.c lwip_init.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timers.c lwip_udp.c
  group drivers
    ../../mbed-os/hal/targets/hal/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_mpu.c fsl_mpu.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group fat
    ../../IoT-OS/external/mbedfs/fat/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
  group flash-journal
    ../../mbed-os/features/storage/FEATURE_STORAGE/flash-journal/: flash_journal.h
  group flash-journal-strategy-sequential
    ../../mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential/: config.h flash_journal_private.h flash_journal_strategy_sequential.h strategy.c support_funcs.c support_funcs.h
  group greentea-client
    ../../mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_serial.h test_env.h
  group hal
    ../../mbed-os/hal/hal/: analogin_api.h analogout_api.h buffer.h can_api.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h us_ticker_api.h
  group httpclient-c
    ../../IoT-OS/src/httpclient-c/: baidu_http_client_c.c baidu_http_client_c.h baidu_http_client_log.h baidu_libc_macro.h baidu_mbed_soc_wrapper.cpp baidu_mbed_soc_wrapper.h
  group include
    ../../IoT-OS/src/iot-baidu-ca/include/: baidu_ca.h baidu_ca_types.h
    ../../IoT-OS/external/mbed_client/mbed-client-c/source/libCoap/src/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    ../../IoT-OS/external/mbed_client/mbed-client-c/source/libNsdl/src/include/: sn_grs.h
  group iot-baidu-ca-adapter
    ../../IoT-OS/src/iot-baidu-ca-adapter/: baidu_ca_adapter.cpp baidu_ca_adapter.h baidu_ca_memory_adapter.cpp baidu_ca_memory_adapter.h baidu_ca_network_adapter.cpp baidu_ca_network_adapter.h baidu_ca_network_socket.cpp baidu_ca_network_socket.h
  group iot-baidu-ca-scheduler
    ../../IoT-OS/src/iot-baidu-ca-scheduler/: baidu_ca_configuration.cpp baidu_ca_configuration.h baidu_ca_handler.cpp baidu_ca_handler.h baidu_ca_message.cpp baidu_ca_message.h baidu_ca_scheduler.cpp baidu_ca_scheduler.h
  group ipv4
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/core/ipv4/: lwip_autoip.c lwip_icmp.c lwip_igmp.c lwip_inet.c lwip_inet_chksum.c lwip_ip.c lwip_ip_addr.c lwip_ip_frag.c
  group libspeex
    ../../IoT-OS/external/speex/libspeex/: _kiss_fft_guts.h arch.h bits.c cb_search.c cb_search.h cb_search_arm4.h cb_search_bfin.h cb_search_sse.h exc_10_16_table.c exc_10_32_table.c exc_20_32_table.c exc_5_256_table.c exc_5_64_table.c exc_8_128_table.c fftwrap.c fftwrap.h filterbank.c filterbank.h filters.c filters.h filters_arm4.h filters_bfin.h filters_sse.h fixed_arm4.h fixed_arm5e.h fixed_bfin.h fixed_debug.h fixed_generic.h gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c jitter.c kiss_fft.c kiss_fft.h kiss_fftr.c kiss_fftr.h lbr_48k_tables.c lpc.c lpc.h lpc_bfin.h lsp.c lsp.h lsp_bfin.h lsp_tables_nb.c ltp.c ltp.h ltp_arm4.h ltp_bfin.h ltp_sse.h math_approx.c math_approx.h mdf.c misc.c misc.h misc_bfin.h modes.c modes.h nb_celp.c nb_celp.h preprocess.c pseudofloat.h quant_lsp.c quant_lsp.h quant_lsp_bfin.h resample.c sb_celp.c sb_celp.h smallft.c smallft.h speex.c speex_callbacks.c speex_header.c stack_alloc.h stereo.c vbr.c vbr.h vorbis_psy.c vorbis_psy.h vq.c vq.h vq_arm4.h vq_bfin.h vq_sse.h window.c
  group lwip
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/: lwipopts.h
  group lwip-interface
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/: eth_arch.h EthernetInterface.cpp EthernetInterface.h lwip_stack.c lwip_stack.h lwipopts.h wifi_arch.h WiFiStackInterface.cpp WiFiStackInterface.h
  group main
    ../../IoT-OS/main/: duer_app.cpp duer_app.h events.cpp events.h main.cpp recording30s_spx.c singsong_wav_spx.c
  group mbed-client-libservice
    ../../IoT-OS/external/mbed_client/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
  group mbed-trace
    ../../IoT-OS/external/mbed_client/mbed-trace/mbed-trace/: mbed_trace.h
  group mbedtls
    ../../mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group media-player
    ../../IoT-OS/src/media-player/: baidu_media_play.cpp baidu_media_play.h
  group mp3_data_mgr
    ../../IoT-OS/src/mp3_data_mgr/: baidu_mp3_data_mgr.cpp baidu_mp3_data_mgr.h
  group mp3dec
    ../../IoT-OS/external/mp3dec/: mp3dec.c mp3tabs.c
  group netif
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/include/netif/: etharp.h ppp_oe.h slipif.h
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/netif/: lwip_etharp.c lwip_ethernetif.c lwip_slipif.c
  group network-socket
    ../../mbed-os/features/net/network-socket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiInterface.h
  group nsdl-c
    ../../IoT-OS/external/mbed_client/mbed-client-c/nsdl-c/: sn_coap_header.h sn_coap_protocol.h sn_nsdl.h sn_nsdl_lib.h
  group platform
    ../../IoT-OS/external/mbed_client/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
  group ppp
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/netif/ppp/: auth.h chap.h chpms.h fsm.h ipcp.h lcp.h lwip_auth.c lwip_chap.c lwip_chpms.c lwip_fsm.c lwip_ipcp.c lwip_lcp.c lwip_magic.c lwip_md5.c lwip_pap.c lwip_ppp.c lwip_ppp_oe.c lwip_randm.c lwip_vj.c magic.h md5.h pap.h ppp.h pppdebug.h randm.h vj.h
  group pub
    ../../IoT-OS/external/mp3dec/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group real
    ../../IoT-OS/external/mp3dec/real/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group recorder
    ../../IoT-OS/src/recorder/: baidu_os_recorder.cpp baidu_os_recorder.h baidu_os_speex_encoder.cpp baidu_os_speex_encoder.h
    ../src/recorder/: baidu_os_recorder_manager.cpp
    ../src/media/: baidu_os_media_base.cpp baidu_os_media_base.h
  group rtos
    ../../mbed-os/rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group sd
    ../../IoT-OS/external/mbedfs/sd/: SDFileSystem.cpp SDFileSystem.h
  group snmp
    ../../mbed-os/features/net/FEATURE_IPV4/lwip-interface/lwip/core/snmp/: lwip_asn1_dec.c lwip_asn1_enc.c lwip_mib2.c lwip_mib_structs.c lwip_msg_in.c lwip_msg_out.c
  group source
    ../../IoT-OS/src/iot-baidu-ca/source/: baidu_ca.c baidu_ca_coap.c baidu_ca_coap.h baidu_ca_coap_ep.c baidu_ca_coap_ep.h baidu_ca_conf.c baidu_ca_conf.h baidu_ca_debug.c baidu_ca_debug.h baidu_ca_hashcode.c baidu_ca_hashcode.h baidu_ca_internal.h baidu_ca_mbedtls_config.h baidu_ca_mbedtrace.c baidu_ca_mbedtrace.h baidu_ca_memory.c baidu_ca_memory.h baidu_ca_mutex.c baidu_ca_mutex.h baidu_ca_ns_list.c baidu_ca_nsdl_adapter.c baidu_ca_nsdl_adapter.h baidu_ca_random.c baidu_ca_random.h baidu_ca_timestamp.c baidu_ca_timestamp.h baidu_ca_trans_encrypted.c baidu_ca_trans_encrypted.h baidu_ca_trans_wrapper.c baidu_ca_trans_wrapper.h baidu_ca_transport.c baidu_ca_transport.h baidu_ca_util_network.c baidu_ca_util_network.h ns_list.h ns_types.h threading_alt.h
    ../../mbed-os/features/storage/FEATURE_STORAGE/cfstore/source/: cfstore_config.h cfstore_debug.h cfstore_fnmatch.c cfstore_fnmatch.h cfstore_list.h cfstore_test.c cfstore_test.h cfstore_utest.h cfstore_uvisor.h configuration_store.c
    ../../mbed-os/features/frameworks/greentea-client/source/: greentea_serial.cpp test_env.cpp
    ../../mbed-os/features/frameworks/unity/source/: unity.c
    ../../mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
  group speex
    ../../IoT-OS/external/speex/include/speex/: speex.h speex_bits.h speex_callbacks.h speex_config_types.h speex_echo.h speex_header.h speex_jitter.h speex_preprocess.h speex_resampler.h speex_stereo.h speex_types.h
  group src
    ../../mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../IoT-OS/external/mbed_client/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ../../IoT-OS/external/mbed_client/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_nsdl.c
  group storage_abstraction
    ../../mbed-os/hal/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group unity
    ../../mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group utest
    ../../mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    ../../mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group wavfmt
    ../../IoT-OS/external/speex/wavfmt/: wavfmt.cpp wavfmt.h
  group ota
    ../src/iot-baidu-ota/: baidu_iot_ota_coap_downloader.cpp baidu_iot_ota_coap_downloader.h baidu_iot_ota_decompresser.cpp baidu_iot_ota_decompresser.h baidu_iot_ota_downloader.h baidu_iot_ota_http_downloader.cpp baidu_iot_ota_http_downloader.h baidu_iot_ota_manager.cpp baidu_iot_ota_manager.h baidu_iot_ota_reporter.cpp baidu_iot_ota_reporter.h coap_client.cpp coap_client.h url.cpp url.h shared_buffer.cpp shared_buffer.h baidu_iot_ota_log.h
  group ota_unpack
    ../src/iot-baidu-ota/baidu_ota_unpack/: new_firmware_image_unpack_tool.cpp new_firmware_image_unpack_tool.h
    ../src/iot-baidu-ota/baidu_ota_unpack/ota/inc/: datacollector.h decompress.h fs.h pack_include.h package_api.h verification.h cJSON.h
    ../src/iot-baidu-ota/baidu_ota_unpack/ota/src/: datacollector.c decompress.c fs.c package_api.c verification.c cJSON.c
    ../src/iot-baidu-ota/baidu_ota_unpack/zliblite/: adler32.c compress.c crc32.c crc32.h deflate.c deflate.h infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h trees.c trees.h uncompr.c zconf.h zlib.h zutil.c zutil.h
  group TARGET_RDA
    ../boards/TARGET_RDA/: package_scanner.cpp package_scanner.h
